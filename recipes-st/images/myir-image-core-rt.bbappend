IMAGE_INSTALL:append:stm32mprtcommon = "stress-ng rt-tests hwlatdetect"
