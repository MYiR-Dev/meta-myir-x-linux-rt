FILESEXTRAPATHS:prepend := "${THISDIR}:${THISDIR}/${PN}:"

SRCREV:stm32mprtcommon = "2ef40f64b9ed2f386b0a973fd61897c7e4850c0b"
EXT_DT_RELEASE:stm32mprtcommon = "stm32mp-rt-r3"
